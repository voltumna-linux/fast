require recipes-core/images/voltumna-sre.inc
require include/runtime.inc
VARIANT = "Fast Device (Runtime)"
