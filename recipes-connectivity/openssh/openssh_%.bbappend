FILES:${PN} += " \
    ${ROOT_HOME}/.ssh \
    "

do_install:append() {
	install -d ${D}${ROOT_HOME}/.ssh
	cat <<-__EOF__ >> ${D}${ROOT_HOME}/.ssh/authorized_keys
ssh-rsa AAAAB3NzaC1yc2EAAAADAQABAAACAQDFfR5uv0z2pDX0eO+SzUBTQjP8kXKcbKo1LNbMsP2fchTo0OsNbRWt73mWPth6KcUySxuDhFUP9GIw91or17T2LuJcSeRBfIC9u1/Uf5J1DtQw+KTZ9doDD8VIDfeecRRzfL/UggRy9fVRt088H9I3e+v+AFWeX3BUd8A12fRa76AyNVwt5S9vx1hFg/Drlbg2ExpbflLhbf8wu/fHHEGORa24HdzVJtrTQ6HsULQ/MeTYkyHFgCywRG52p0ySmMAI7VS2E9RTPcL0cPGd6okBj3G70UX0DyUJ/3OnYtbW1fPtvZk5VQasTiYqInXWOo3qmeU6N1ZafxaZrdZzrgyplr/RJFU/xtakBzY37r9c3E0lL1CCMU+4EV/BM9XUUtazmppNQ+RZeJDGEK1JInk5xMsWi2MacRlKonRjNw6ExJPaFxcjQF1jJtrnVmkrv2yfFNDb88VZ23PN7nH5MIqEeNXtRmqIphYNav0c+RxNPoGCeoXIjSJBKTlm7tcEVnFNIwW3NRnutrdDIhfODepzRjIsNL9nzS/HcbILWTlJSAjt/N7mRwdOwFkO/c24V60pvUoYIPWRH6sJ97AqTg+t2wx8qxhXNezs3Eft/POi0KQxHpIDuocLYZV+aIDERA7mdUBd31rO4LvLnPMsqc1T3EBBoRLCH7P3i34qMoFahQ== inau@inau
	__EOF__
}
